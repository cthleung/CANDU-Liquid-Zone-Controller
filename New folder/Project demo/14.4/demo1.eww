<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\1.1\1.1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Project Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
