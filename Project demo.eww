<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project demo\project demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\Desktop\Project demo\14.4\Project Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
